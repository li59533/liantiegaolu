# Keil uVision project adc16_low_power_async_dma.uvprojx, settings and files
target adc16_low_power_async_dma Debug (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: adc16_low_power_async_dma.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL26Z128VLH4, FRDM_KL26Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../devices/MKL26Z4/drivers;../../../../../devices/MKL26Z4/utilities;../../../../../devices/MKL26Z4
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL26Z128xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL26Z4/arm/: startup_MKL26Z4.s
    ../../../../../devices/MKL26Z4/: system_MKL26Z4.c system_MKL26Z4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL26Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_lptmr.c fsl_lptmr.h fsl_gpio.h fsl_gpio.c fsl_clock.h fsl_clock.c fsl_adc16.c fsl_adc16.h fsl_dma.h fsl_dma.c fsl_dmamux.h fsl_dmamux.c fsl_sim.h fsl_sim.c fsl_pmc.h fsl_pmc.c fsl_common.h fsl_common.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h
  group source
    ../: adc16_low_power_async_dma.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL26Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target adc16_low_power_async_dma Release (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: adc16_low_power_async_dma.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL26Z128VLH4, FRDM_KL26Z, FREEDOM
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL26Z128xxx4_flash.scf
  link misc: --remove
