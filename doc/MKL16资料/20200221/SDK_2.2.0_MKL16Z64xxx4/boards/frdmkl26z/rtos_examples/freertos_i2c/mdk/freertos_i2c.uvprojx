# Keil uVision project freertos_i2c.uvprojx, settings and files
target freertos_i2c Debug (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_i2c.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_MKL26Z128VLH4, FSL_RTOS_FREE_RTOS, FRDM_KL26Z, FREEDOM
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM0;../../../../../rtos/freertos_9.0.0/Source/include;../../../../../CMSIS/Include;../../../../../devices;..;../../..;../../../../../rtos/freertos_9.0.0/Source;../../../../../devices/MKL26Z4/drivers;../../../../../devices/MKL26Z4/utilities;../../../../../devices/MKL26Z4
  asm define: DEBUG
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  scatter file: MKL26Z128xxx4_flash.scf
  link misc: --remove
  group startup
    ../../../../../devices/MKL26Z4/arm/: startup_MKL26Z4.s
    ../../../../../devices/MKL26Z4/: system_MKL26Z4.c system_MKL26Z4.h
  group freertos:portable
    ../../../../../rtos/freertos_9.0.0/Source/portable/RVDS/ARM_CM0/: port.c fsl_tickless_systick.c fsl_tickless_generic.h portmacro.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MKL26Z4/drivers/: fsl_lpsci.h fsl_lpsci.c fsl_uart.h fsl_uart.c fsl_port.h fsl_i2c.h fsl_i2c.c fsl_common.h fsl_common.c fsl_gpio.h fsl_gpio.c fsl_smc.h fsl_smc.c fsl_flash.c fsl_flash.h fsl_clock.h fsl_clock.c
  group drivers-freertos
    ../../../../../devices/MKL26Z4/drivers/: fsl_i2c_freertos.h fsl_i2c_freertos.c
  group freertos
    ../../../../../rtos/freertos_9.0.0/Source/portable/MemMang/: heap_4.c
    ../../../../../rtos/freertos_9.0.0/Source/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h deprecated_definitions.h freertos_tasks_c_additions.h
    ../../../../../rtos/freertos_9.0.0/Source/: croutine.c list.c queue.c tasks.c timers.c event_groups.c
  group source
    ../: FreeRTOSConfig.h freertos_i2c.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../devices/MKL26Z4/utilities/: fsl_debug_console.c fsl_debug_console.h
target freertos_i2c Release (ARM-ADS)
  device: MKL26Z128xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0+")
  output: freertos_i2c.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_MKL26Z128VLH4, FSL_RTOS_FREE_RTOS, FRDM_KL26Z, FREEDOM
  c misc: as above
  c include: as above
  asm include: ..;../../..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MKL26Z128xxx4_flash.scf
  link misc: --remove
